# IAR project sensor_TH06.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403AVGT7_v2 ArteryTek -AT32F403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403AVGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1
  ICCARM.CCIncludePath2: $PROJ_DIR$; cmsis; cmsis\cm4; drivers\inc; board; cmsis\cm4\device_support; cmsis\cm4\core_support; ssd_1309; TH06; i2c; i2c_application_library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group board
    board/: at32f403a_407.h at32f403a_407_clock.c at32f403a_407_clock.h at32f403a_407_conf.h at32f403a_407_int.c at32f403a_407_int.h board.c board.h
  group cmsis
    cmsis/cm4/device_support/startup/iar/: startup_at32f403a_407.s
    cmsis/cm4/device_support/: system_at32f403a_407.c
  group firmware
    drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group i2c
    i2c/: i2c.c i2c.h
  group middleware
    i2c_application_library/: i2c_application.c i2c_application.h
  group ssd_1309
    ssd_1309/: gpio.c gpio.h SSD_1309.c SSD_1309.h
  group TH06
    TH06/: TH06.c TH06.h
